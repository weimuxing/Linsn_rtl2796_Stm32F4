# Keil uVision project Q2_4k.uvprojx, settings and files
target STM32F4XX_DEBUG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4XX_DEBUG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM322xG_EVAL,STM32F40_41xxx, USE_STDPERIPH_DRIVER,USE_USB_OTG_HS,USE_EMBEDDED_PHY,_UART_DEBUG_,LING_XIN
  c include: ..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\Libraries\FATFS\src;..\Libraries\FATFS\src\drivers;..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Common;..\Libraries\CORE;..\Driver;..\Driver\TIMER;..\PICTURE;..\malloc;..\usb;..\Driver\LCD;..\USMART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: control.c EDID.c keyBoardStatus.c main.c langStr.c langStr_CN.c langStr_EN.c LCD.c menu.c menuData.c processKey.c rs232command.c SysTick.c uart.c update_from_fatfs.c updateFirmware.c UserPref.c VideoFormatTable.c fatfs.c
    ../Common/: stm32f4xx_it.c system_stm32f4xx.c
  group Driver
    ../Driver/: D74HC165.c D74HC595.c drvSSD1322.c fanControl.c fonts.c FPGA.c I2C.c I2CEEPROM.c keyScan.c Picture.c pipe.c rotaryEncoder.c SiI9134.c soft_spi.c spi.c spi_flash.c usb-rs232.c RTD2796.c IDT5P49V5901.c IDT_Timing_Commander.c
  group MALLOC
    ../malloc/: malloc.c
  group MDK-ARM
    ../Libraries/CORE/: startup_stm32f40_41xxx.s
  group USB User
    ../usb/: usb_bsp.c usbh_usr.c
  group Libraries/STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_fsmc.c
  group Libraries/STM32_USB_HOST_Library
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group FATFS
    ../Libraries/FATFS/src/: diskio.c ff.c
  group LCD
    ../Driver/LCD/: Drv_LCD.c
  group Usmart
    ../USMART/: usmart.c usmart_config.c usmart_str.c
target STM32F4XX_RELEASE (ARM-ADS)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F4XX_RELEASE
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OUTPUT_MID\Q2_4k_207_MID.bin ..\OUTPUT_MID\Q2_4k_207_MID.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM322xG_EVAL, STM32F2XX, USE_STDPERIPH_DRIVER, USE_USB_OTG_FS,SOURCE_RELEASE
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\usb;..\Libraries\STM32_USB_OTG_Driver\inc;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\Driver;.\inc;..\Libraries\FATFS\src;..\Libraries\FATFS\src\drivers;..\PICTURE;..\malloc;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
